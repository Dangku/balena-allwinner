# Flash to internal eMMC - kernel always enumerates emmc as mmcblk2
INTERNAL_DEVICE_KERNEL_nanopi-neo-air = "mmcblk2"

INTERNAL_DEVICE_KERNEL_orangepi-plus2 = "mmcblk2"

INTERNAL_DEVICE_KERNEL_bananapi-m2-plus = "mmcblk2"

INTERNAL_DEVICE_KERNEL_bananapi-m2-zero = "mmcblk2"

INTERNAL_DEVICE_KERNEL_bananapi-m64 = "mmcblk2"

INTERNAL_DEVICE_KERNEL_bananapi-m3 = "mmcblk2"

INTERNAL_DEVICE_KERNEL_bananapi-m2-ultra = "mmcblk2"

INTERNAL_DEVICE_KERNEL_bananapi-m2-berry = "mmcblk2"

INTERNAL_DEVICE_KERNEL_bananapi-m2-magic = "mmcblk2"
